# Keil uVision project 01.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver;.\Driver_DIY;.\Lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c
  group Driver
    ./Driver/: RCC.c RCC.h GPIO.c GPIO.h AFIO.c AFIO.h EXTI.c EXTI.h TYPE.h TIME.c TIME.h ADC.c ADC.h UART.c UART.h I2C.c I2C.h SPI.c SPI.h
  group Lib
    ./Lib/: ST7789.c ST7789.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
